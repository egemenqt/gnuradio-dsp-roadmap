options:
  parameters:
    author: egemenyigit
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: project_02
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_range
  id: variable_qtgui_range
  parameters:
    start: 446.28e6
    step: 1e3
    stop: 446.4e6
    value: 446.28e6
  states: {}
- name: gain_range
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100e3 '
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq_range
    fftsize: '8192'
    grid: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq_range
    gain0: gain_range
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
